# Keil uVision project avalon-rig-adc.uvproj, settings and files
target avalon-rig (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: avalon-rig-adc
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\CMSIS;..\Lib\CMSIS\Startup;..\Lib\FWLIB\inc;..\User\Header
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Lib/CMSIS/Startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../Lib/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Appl
    ../User/Appl/: main.c
  group Driver
    ../User/Driver/: stm32f10x_it.c
